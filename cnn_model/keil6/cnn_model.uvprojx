# Keil uVision project cnn_model.uvprojx, settings and files
target mnist_cnn (6240000::V6.24::ARMCLANG)
  device: AMAP42KL-KBR Ambiq Micro
  pack: AmbiqMicro.Apollo_DFP.1.5.4
  cpu: IROM(0x00018000,0x001E8000) IRAM(0x10000000,0x60000) CPUTYPE("Cortex-M4") FPU2 CLOCK(48000000) ELITTLE
  output: convolution
  AfterMake: fromelf --bin --output bin\mnist_cnn.bin bin\mnist_cnn.axf
  AfterMake: fromelf -cedrst --output bin\mnist_cnn.txt bin\mnist_cnn.axf
  c flags: Optim=1 oTime=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=1 wLevel=3
  c define: AM_PACKAGE_BGA AM_PART_APOLLO4L keil6 ARM_MATH_CM4 ARM_MATH_DSP
  c include: ..\..\AmbiqSuite_R4.5.0\boards\apollo4l_blue_evb\bsp;..\..\AmbiqSuite_R4.5.0\mcu\apollo4l\hal\mcu;..\..\AmbiqSuite_R4.5.0\mcu\apollo4l;..\..\AmbiqSuite_R4.5.0\mcu\apollo4l\regs;..\..\AmbiqSuite_R4.5.0\utils;..\..\AmbiqSuite_R4.5.0\CMSIS\ARM\Include;..\..\CMSIS_5-5.9.0\CMSIS_5-5.9.0\CMSIS\NN\Include;..\..\CMSIS_5-5.9.0\CMSIS_5-5.9.0\CMSIS\Core\Include;..\src
  memory RVCT4: ROM 0x0 size 0x100000
  memory RVCT9: RAM 0x10000000 size 0x60000
  scatter file: .\linker_script.sct
  link misc: ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/libam_hal.lib --undefined=__scatterload_copy
  group src
    ../src/: am_resources.c mnist_test_inputs.h model_config.h mnist_cnn.c
  group utils
    ../../../../../../utils/: am_util_delay.c am_util_faultisr.c am_util_id.c am_util_stdio.c am_util_string.c
  group keil6
    ../keil6/: startup_keil6.s
  group lib
    ../../../../../../mcu/apollo4l/hal/mcu/keil6/bin/: libam_hal.lib
    ../../../../bsp/keil6/bin/: libam_bsp.lib
    ../../../../../../CMSIS/ARM/Lib/ARM/: arm_cortexM4lf_math.lib
  group cnn_mnist
    C:/Users/Dell/Namuunaa_Thesis/CMSIS_5-5.9.0/CMSIS_5-5.9.0/CMSIS/NN/Source/PoolingFunctions/: arm_pool_q7_HWC.c
    C:/Users/Dell/Namuunaa_Thesis/CMSIS_5-5.9.0/CMSIS_5-5.9.0/CMSIS/NN/Source/ActivationFunctions/: arm_relu_q7.c
    C:/Users/Dell/Namuunaa_Thesis/CMSIS_5-5.9.0/CMSIS_5-5.9.0/CMSIS/NN/Source/SoftmaxFunctions/: arm_softmax_q7.c
    C:/Users/Dell/Namuunaa_Thesis/CMSIS_5-5.9.0/CMSIS_5-5.9.0/CMSIS/NN/Source/ConvolutionFunctions/: arm_convolve_HWC_q7_basic.c arm_convolve_HWC_q7_fast.c
    C:/Users/Dell/Namuunaa_Thesis/CMSIS_5-5.9.0/CMSIS_5-5.9.0/CMSIS/NN/Source/FullyConnectedFunctions/: arm_fully_connected_q7.c
