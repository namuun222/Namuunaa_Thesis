<?xml version="1.0" encoding="UTF-8" standalone="no" ?>
<ProjectWorkspace xmlns:xsi="http://www.w3.org/2001/XMLSchema-instance" xsi:noNamespaceSchemaLocation="project_mpw.xsd">

  <SchemaVersion>1.0</SchemaVersion>

  <Header>### uVision Project, (C) Keil Software</Header>

  <WorkspaceName>practice</WorkspaceName>

  <project>
    <PathAndName>.\hello_world_uart\keil6\hello_world_uart.uvprojx</PathAndName>
    <NodeIsExpanded>1</NodeIsExpanded>
  </project>

  <project>
    <PathAndName>C:\Users\Dell\Namuunaa_Thesis\nvm_read_write\keil6\nvm_read_write.uvprojx</PathAndName>
  </project>

  <Sle7>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <Apps>
      <bAna>0</bAna>
      <nLevel>0</nLevel>
    </Apps>
    <ExecApp></ExecApp>
    <CfgApp></CfgApp>
    <bHex>0</bHex>
    <bList>0</bList>
    <buGlb>0</buGlb>
    <bCase>0</bCase>
    <szMisc></szMisc>
    <bRunPL>0</bRunPL>
    <UserCmd>
      <bRun>0</bRun>
      <bSpawn>0</bSpawn>
      <nSel>0</nSel>
    </UserCmd>
  </Sle7>

</ProjectWorkspace>
